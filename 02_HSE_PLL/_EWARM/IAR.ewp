# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\CMSIS\Device; ..\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR.bin
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group _EWARM
    ./: startup_stm32f407xx.s stm32f407xx_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group CMSIS/Include
    ../CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h
  group user/inc
    ../user/inc/: RCC.h
  group user/src
    ../user/src/: RCC.c
